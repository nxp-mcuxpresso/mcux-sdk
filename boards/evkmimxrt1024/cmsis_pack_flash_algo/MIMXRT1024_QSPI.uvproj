# Keil uVision project MIMXRT1024_QSPI.uvproj, settings and files
target RT1024 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: MIMXRT1024_QSPI
  AfterMake: cmd.exe /C copy "Output\%L" "MIMXRT1024_QuadSPI_4KB_SEC.FLM"
  AfterMake: fromelf --bincombined -o "$L@L.bin" "#L"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: CPU_MIMXRT1024DAG5A
  c include: ..\..\..\CMSIS\Include;..\..\..\devices\MIMXRT1024;..\..\..\devices\MIMXRT1024\drivers;..\..\..\platform\drivers\common;.\Sources
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group Sources
    ./Sources/: fsl_romapi.c fsl_romapi.h
